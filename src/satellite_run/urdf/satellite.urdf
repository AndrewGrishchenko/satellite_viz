Commit message: code cleaned

File: src/satellite_run/urdf/satellite.urdf (robot description, URDF)
Before this commit: robot satellite, 3 links, 2 joints
Links:
- link end_NAME: geometry visual sphere radius=0.25
